options:
  parameters:
    generate_options: qt_gui
    id: Final_MultiChannel
    output_language: python
    title: Final_MultiChannel
  states: {}

blocks:
- name: AIS_samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: CH13
  id: variable_qtgui_range
  parameters:
    label: CH13
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: CH13_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: CH16
  id: variable_qtgui_range
  parameters:
    label: CH16
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: CH16_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: NOAA
  id: variable_qtgui_range
  parameters:
    label: NOAA
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
    widget: dial
  states: {}
- name: NOAA_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '9000000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: channel_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: channel_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '192000'
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '192000'
  states: {}
- name: analog_wfm_rcv_0_0_1_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '192000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_1_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '2400000'
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: '8200000'
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_3
  id: blocks_freqshift_cc
  parameters:
    freq: 2.525e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_4
  id: blocks_freqshift_cc
  parameters:
    freq: 2.475e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_5
  id: blocks_freqshift_cc
  parameters:
    freq: 8.475e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_6
  id: blocks_freqshift_cc
  parameters:
    freq: 8.35e6
    sample_rate: samp_rate
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: 1/5
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: 1/5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: NOAA_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: CH16_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: CH13_gain
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\LEDukat\Documents\SDR\6ChannelWeather06NOV.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\LEDukat\Documents\SDR\static.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_wavfile_sink_0_0_1_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\LEDukat\Documents\SDR\static.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '5'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '5'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '12500'
    decim: '5'
    gain: '1'
    samp_rate: AIS_samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '12500'
    decim: '5'
    gain: '1'
    samp_rate: AIS_samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: What would happen if I fm demoded the entire spectrum then filtered it?
  states: {}
- name: note_1
  id: note
  parameters:
    note: Ch16
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Ch13
  states: {}
- name: note_2
  id: note
  parameters:
    note: NOAA
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '''NOAA'''
    name: '"NOAA"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '''Channel 16'''
    name: '"Channel 16"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '''Channel 13'''
    name: '"Channel 13"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '''DSC'''
    name: '"DSC"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '''AIS Channel 2'''
    name: '"AIS Channel 2"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '''AIS Channel 1'''
    name: '"AIS Channel 1"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Og"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: AIS_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Og"'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_sink_x_0_1_0_0
  id: qtgui_sink_x
  parameters:
    bw: AIS_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Og"'
    showports: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '375'
    interp: '8'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '375'
    interp: '8'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '375'
    interp: '8'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '36'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '36'
    interp: '1'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '9000000'
    center_freq0: '165000000'
    gain0: '70'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: AIS Channel 1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: AIS Channel 2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: DSC
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: AIS Channel 1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: AIS Channel 2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: DSC
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8081'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_wfm_rcv_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [analog_wfm_rcv_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_rcv_0_0_1_0, '0', blocks_multiply_const_vxx_1_1_0, '0']
- [analog_wfm_rcv_0_0_1_0, '0', blocks_wavfile_sink_0_0_1_0, '0']
- [analog_wfm_rcv_0_0_1_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_sink_x_0_1_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_sink_x_0_1_0_0, '0']
- [blocks_freqshift_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_freqshift_cc_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_freqshift_cc_3, '0', qtgui_freq_sink_x_1_1, '0']
- [blocks_freqshift_cc_3, '0', rational_resampler_xxx_1, '0']
- [blocks_freqshift_cc_4, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_freqshift_cc_4, '0', rational_resampler_xxx_1_0, '0']
- [blocks_freqshift_cc_5, '0', qtgui_freq_sink_x_1, '0']
- [blocks_freqshift_cc_6, '0', rational_resampler_xxx_0_0_1_0, '0']
- [blocks_moving_average_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_moving_average_xx_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_1_1_0, '0', audio_sink_0_0_1_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_1, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_1_0, '0']
- [qtgui_sink_x_0, freq, uhd_usrp_source_0, command]
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_rcv_0_0, '0']
- [rational_resampler_xxx_0_0_1_0, '0', analog_wfm_rcv_0_0_1_0, '0']
- [rational_resampler_xxx_0_1, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0_1_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1_0, '0', low_pass_filter_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_6, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_1, '0']
- [uhd_usrp_source_0, '0', virtual_sink_2, '0']
- [virtual_source_0, '0', blocks_freqshift_cc_3, '0']
- [virtual_source_1, '0', blocks_freqshift_cc_4, '0']
- [virtual_source_2, '0', blocks_freqshift_cc_5, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
