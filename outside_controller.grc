options:
  parameters:
    generate_options: qt_gui
    id: freq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 87.9e6
  states: {}
- name: frequency_slider
  id: variable_qtgui_range
  parameters:
    start: 87.9*10**6
    step: 200*10**3
    stop: 107.9*10**6
    value: 87.9*10**6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2*10**6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 48000*4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '12'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: frequency
    clock_rate: 30.72e6
    rx_agc0: Enabled
    samp_rate: samp_rate
    stream_args: peak=0.003906
    sync: none
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8081'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
